options:
  parameters:
    author: root
    generate_options: no_gui
    id: qpsk_overshadowing
    output_language: python
    run_options: run
    title: qpsk_overshadowing
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {}
- name: blocks_head_0_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: overshadow_strength
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]*(1024-padding_bytes)+[1]*(1024+padding_bytes+padding_bytes)+[0]*(1024-padding_bytes)'
  states: {}
- name: channel_noise_attacker
  id: parameter
  parameters:
    label: 'Attacker: Channel Noise'
    type: intx
    value: '1'
  states: {}
- name: channel_noise_victim
  id: parameter
  parameters:
    label: 'Victim: Channel Noise'
    type: intx
    value: '1'
  states: {}
- name: frequency_offset_attacker
  id: parameter
  parameters:
    label: 'Attacker: Frequency Offset'
    type: eng_float
    value: '0'
  states: {}
- name: frequency_offset_victim
  id: parameter
  parameters:
    label: 'Victim: Frequency Offset'
    type: eng_float
    value: '0'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: 'Input file: bytes to overshadow'
    type: str
    value: /data/satnogs/AQUA_PADDED.raw
  states: {}
- name: noise_voltage_attacker
  id: parameter
  parameters:
    label: 'Attacker: Noise Voltage'
    type: eng_float
    value: '0.0001'
  states: {}
- name: noise_voltage_victim
  id: parameter
  parameters:
    label: 'Victim: Noise Voltage'
    type: eng_float
    value: '0.0001'
  states: {}
- name: num_packets
  id: parameter
  parameters:
    label: Number of Packets
    type: intx
    value: '1024'
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: Output file
    type: str
    value: /data/satnogs/OVERSHADOW.raw
  states: {}
- name: overshadow_strength
  id: parameter
  parameters:
    label: Overshadowing Multiplier
    type: eng_float
    value: '5'
  states: {}
- name: padding_bytes
  id: parameter
  parameters:
    label: Padding Bytes
    type: intx
    value: '32'
  states: {}
- name: qpsk_decoder_0
  id: qpsk_decoder
  parameters:
    eq_gain: '0.01'
    phase_bw: 6.28/100.0
    timing_loop_bw: 6.28/100.0
  states: {}
- name: qpsk_encoder_0
  id: qpsk_encoder
  parameters:
    excess_bw: '0.350'
    freq_offset: frequency_offset_victim
    noise: channel_noise_victim
    noise_volt: noise_voltage_victim
    time_offset: timing_offset_victim
  states: {}
- name: qpsk_masked_encoder_0
  id: qpsk_masked_encoder
  parameters:
    excess_bw: '0.350'
    freq_offset: frequency_offset_attacker
    noise: channel_noise_attacker
    noise_volt: noise_voltage_attacker
    time_offset: timing_offset_attacker
  states: {}
- name: timing_offset_attacker
  id: parameter
  parameters:
    label: 'Attacker: Timing Offset'
    type: eng_float
    value: '1'
  states: {}
- name: timing_offset_victim
  id: parameter
  parameters:
    label: 'Victim: Timing Offset'
    type: eng_float
    value: '1'
  states: {}

connections:
- [analog_agc3_xx_0, '0', qpsk_decoder_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_head_0_0, '0']
- [blocks_add_xx_0, '0', analog_agc3_xx_0, '0']
- [blocks_file_source_1, '0', blocks_head_0_0_0, '0']
- [blocks_head_0_0, '0', qpsk_encoder_0, '0']
- [blocks_head_0_0_0, '0', qpsk_masked_encoder_0, '0']
- [blocks_head_0_0_0_0, '0', qpsk_masked_encoder_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_head_0_0_0_0, '0']
- [qpsk_decoder_0, '0', blocks_file_sink_0, '0']
- [qpsk_encoder_0, '0', blocks_add_xx_0, '0']
- [qpsk_masked_encoder_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
