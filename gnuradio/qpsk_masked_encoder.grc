options:
  parameters:
    category: QPSK
    generate_options: hb
    id: qpsk_masked_encoder
    output_language: python
    title: QPSK Masked Encoder
  states: {}

blocks:
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noise
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-noise
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '16'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    label: Excess Bandwidth
    type: eng_float
    value: '0.350'
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: eng_float
    value: '0'
  states: {}
- name: noise
  id: parameter
  parameters:
    label: Channel Noise
    type: intx
    value: '1'
  states: {}
- name: noise_volt
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0.0001'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: mask
    type: byte
  states: {}
- name: time_offset
  id: parameter
  parameters:
    label: Timing Offset
    type: eng_float
    value: '1.000'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_2, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_2, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [pad_source_0, '0', digital_constellation_modulator_0, '0']
- [pad_source_1, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
