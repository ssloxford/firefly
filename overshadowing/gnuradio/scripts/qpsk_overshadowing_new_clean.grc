options:
  parameters:
    author: root
    generate_options: no_gui
    id: qpsk_overshadowing
    output_language: python
    run_options: run
    title: qpsk_overshadowing
  states: {}

blocks:
- name: attacker_gain_multiplier
  id: variable
  parameters:
    value: pow(10, attacker_gain_db/20)
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: Source for simulated satellite signal
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: attacker_gain_db
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: out_file
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/stdout
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    comment: Source for injected signal
    file: in_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {}
- name: blocks_head_0_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*3*num_packets
    type: byte
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/10
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      EIRP + Path Loss
      dBm converted to V
    const: attacker_gain_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      EIRP + Path Loss
      dBm converted to V
    const: '10e-7'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Antenna gain (44.1dB)
    const: '160'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: Antenna gain (-10dB)
    const: '0.316'
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Mask of length 3*1024
      Includes packet of length 1024+2(padding_bytes), surrounded by 0s
    repeat: 'True'
    type: byte
    vector: '[0]*(1024-padding_bytes)+[1]*(1024+padding_bytes+padding_bytes)+[0]*(1024-padding_bytes)'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: No mask
    repeat: 'True'
    type: byte
    vector: '[1]'
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: channel_noise
  id: parameter
  parameters:
    label: Background Channel Noise (V)
    type: eng_float
    value: '0.000001'
  states: {}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: channel_noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_2
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: channel_noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_3
  id: channels_channel_model
  parameters:
    comment: Some amount of processing noise
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: processing_noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: delay
  id: parameter
  parameters:
    label: Delay used for computing bit error rate
    type: intx
    value: '56'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: 'Input file: bytes to overshadow'
    type: str
    value: /data/satnogs/AQUA_PADDED.raw
  states: {}
- name: num_packets
  id: parameter
  parameters:
    label: Number of Packets
    type: intx
    value: '1024'
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: Output file
    type: str
    value: /data/satnogs/OVERSHADOW.raw
  states: {}
- name: padding_bytes
  id: parameter
  parameters:
    label: Padding Bytes
    type: intx
    value: '32'
  states: {}
- name: processing_noise
  id: parameter
  parameters:
    label: Noise in Processing (V)
    type: eng_float
    value: '0.2'
  states: {}
- name: qpsk_decoder_0
  id: qpsk_decoder
  parameters:
    eq_gain: '0.01'
    phase_bw: 6.28/100.0
    timing_loop_bw: 6.28/100.0
  states: {}
- name: qpsk_masked_encoder_0
  id: qpsk_masked_encoder
  parameters:
    excess_bw: '0.350'
    freq_offset: '0'
    noise: '0'
    noise_volt: '0'
    time_offset: '0'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_head_0_0, '0']
- [blocks_add_xx_0, '0', satellites_rms_agc_0_0, '0']
- [blocks_and_const_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_and_const_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_and_const_xx_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [blocks_delay_0_0, '0', blocks_xor_xx_0, '0']
- [blocks_file_source_1, '0', blocks_head_0_0_0, '0']
- [blocks_file_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_head_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_head_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_head_0_0_0, '0', qpsk_masked_encoder_0, '0']
- [blocks_head_0_0_0_0, '0', qpsk_masked_encoder_0, '1']
- [blocks_moving_average_xx_0_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_moving_average_xx_0_0_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_moving_average_xx_0_0_1, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', channels_channel_model_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '1']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_delay_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_head_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_head_0_0_0_0, '0']
- [blocks_xor_xx_0, '0', blocks_not_xx_0, '0']
- [channels_channel_model_1, '0', blocks_multiply_const_vxx_1, '0']
- [channels_channel_model_2, '0', blocks_multiply_const_vxx_2, '0']
- [channels_channel_model_3, '0', satellites_rms_agc_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [qpsk_decoder_0, '0', blocks_file_sink_0, '0']
- [qpsk_decoder_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [qpsk_masked_encoder_0, '0', blocks_multiply_const_vxx_0, '0']
- [satellites_rms_agc_0, '0', qpsk_decoder_0, '0']
- [satellites_rms_agc_0_0, '0', channels_channel_model_3, '0']

metadata:
  file_format: 1
